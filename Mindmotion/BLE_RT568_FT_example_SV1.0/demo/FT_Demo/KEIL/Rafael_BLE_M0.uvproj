# Keil uVision project Rafael_BLE_M0.uvproj, settings and files
target Rafael_BLE_M0 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M032LE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: Rafael_BLE_M0 +hex
  AfterMake: fromelf --bincombined ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\include;..\..\..\porting;..\..\..\include\rf_include;..\..\..\porting\rf_porting;..\..\FT_Demo;..\FT_Func;..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../Library/StdDriver/src/: clk.c gpio.c pdma.c retarget.c spi.c sys.c timer.c uart.c wdt.c fmc.c
  group User
    ../: main.c user.c
    ../FT_Func/: ft_func.c
  group Source Group
    ../../../source/: profile_tab.c bonding_storage.c Rafael_BLE_MM32F032xx_s.lib
  group Porting
    ../../../porting/: mcu_definition.h porting_misc.c porting_spi.c porting_flash.c
    ../../../porting/rf_porting/: porting_LLtimer.c
